FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
             file://0001-UBoot-FTile-PTP-SED-Uboot-changes-for-FM87-1588PTP-SED.patch \
           "
