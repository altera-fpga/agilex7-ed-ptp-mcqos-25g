IMAGE_INSTALL:append = " packetgenerator ptpbridge scripts"
IMAGE_INSTALL:append = " iperf3 bridge-utils util-linux expect"
